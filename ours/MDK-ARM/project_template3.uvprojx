# Keil uVision project project_template3.uvprojx, settings and files
target project_template3 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: project_template3 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Users\sys;..\Users\led;..\Users\guangdian;..\Users\ble;..\Users\callback;..\Users\capture;..\Users\computer_uart;..\Users\graysensor;..\Users\math;..\Users\motor;..\Users\openmv;..\Users\pid;..\Users\sr04;..\Users\oled;..\Users\mpu6050;..\Users\mpu6050\eMPL;..\Users\iic;..\Users\key;..\Users\servo
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/User/Core
    ../Users/sys/: bsp_delay.c
    ./: startup_stm32f407xx.s
    ../Core/Src/: main.c gpio.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User_Hardware
    ../Users/motor/: motor.c
    ../Users/pid/: pid.c
    ../Users/key/: key.c
    ../Users/led/: led.c
    ../Users/guangdian/: guangdian.c
    ../Users/graysensor/: graysensor.c
    ../Users/oled/: oled.c oledfont.c
    ../Users/servo/: servo.c
    ../Users/mpu6050/: mpu6050.c
    ../Users/math/: calculate.c
    ../Users/sr04/: sr04.c
    ../Users/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group User_Uart
    ../Users/computer_uart/: computer_uart.c
    ../Users/ble/: ble.c
    ../Users/openmv/: openmv.c
  group User_Callback
    ../Users/callback/: callback_exti.c callback_tim.c callback_uart.c
software components: CMSIS:CORE 4.3.0
